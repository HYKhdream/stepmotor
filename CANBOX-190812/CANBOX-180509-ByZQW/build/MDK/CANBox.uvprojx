# Keil uVision project CANBox.uvprojx, settings and files
target CANBox (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C1230D5PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x006000) IROM(0x00000000,0x010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CANBox +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c include: ..\..\src\arch\arch_E451\lib;..\..\src\core\hal;..\..\src\core\gui;..\..\src\core\src;..\..\src\core\qwl;..\..\src\arch\arch_E451\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group DriverLib
    ../../src/arch/arch_E451/lib/keil/: Startup.s
    ../../src/arch/arch_E451/lib/src/: gpio.c sysctl.c interrupt.c cpu.c timer.c ssi.c can.c eeprom.c uart.c
  group Arch
    ../../src/arch/arch_E451/src/: arch_board.c arch_irq.c arch_ra8875.c arch_touch.c arch_uart.c
  group Core
    ../../src/core/src/: main.c CanMonitor.c CanFifo.c KeyBoard.c
  group GUI
    ../../src/core/gui/: guilib.c gui_xzq.c gui_menu.c gui_ebrd.c gui_e438.c gui_e481.c gui_input.c
  group hal
    ../../src/core/hal/: hal_E534.c hal_can.c hal_E481.c hal_ebrd.c hal_E438.c hal_E644.c hal_E697.c
  group QWL
    ../../src/core/qwl/: qwl_shell.c
