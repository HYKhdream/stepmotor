# Keil uVision project Project.uvprojx, settings and files
target StepYarn (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F373R8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: StepYarn +hex
  c flags: v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F37X
  c include: ..\..\inc;..\..\STM32F37x_StdPeriph_Driver\startup\Include;..\..\STM32F37x_StdPeriph_Driver\inc;..\..\en.stm32f37x_dsp_stdperiph_lib\STM32F37x_DSP_StdPeriph_Lib_V1.0.0\Libraries\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8007000 size 0x9000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x20003000 size 0x1000
  group User
    ../../src/: main.c stm32f37x_it.c system_stm32f37x.c arch_adc.c arch_gpio.c arch_can.c arch_uart.c arch_time.c arch_dac.c arch_board.c shell.c shell_ctrl.c alert.c step.c massage.c eeprom.c
  group MDK-ARM
    ../../STM32F37x_StdPeriph_Driver/startup/MDK/: startup_stm32f37x.s
  group StdPeriph_Driver
    ../../STM32F37x_StdPeriph_Driver/src/: stm32f37x_adc.c stm32f37x_can.c stm32f37x_cec.c stm32f37x_comp.c stm32f37x_crc.c stm32f37x_dac.c stm32f37x_dbgmcu.c stm32f37x_dma.c stm32f37x_exti.c stm32f37x_flash.c stm32f37x_gpio.c stm32f37x_i2c.c stm32f37x_iwdg.c stm32f37x_misc.c stm32f37x_pwr.c stm32f37x_rcc.c stm32f37x_rtc.c stm32f37x_sdadc.c stm32f37x_spi.c stm32f37x_syscfg.c stm32f37x_tim.c stm32f37x_usart.c stm32f37x_wwdg.c
